options:
  parameters:
    author: dl1ksv
    category: Custom
    generate_options: qt_gui
    id: FMRadio
    title: FM radio to test FCDPROplus
  states: {}

blocks:
- name: Ifgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: IFGain
    min_len: '45'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '59'
    value: '10'
    widget: counter
  states: {}
- name: Lna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label0: 'Off'
    label1: 'On'
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: Mixergain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label0: 'Off'
    label1: 'On'
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: PPM
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,1
    label: set PPM
    min_len: '40'
    orient: Qt.Horizontal
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
    widget: counter
  states: {}
- name: RxFrequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Set Frequency '
    orient: Qt.Horizontal
    start: '80000'
    step: '1'
    stop: '146000'
    value: '94300'
    widget: counter
  states: {}
- name: Volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: Volume
    min_len: '45'
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '50'
    value: '1'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: Volume
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: fcdproplus_fcdproplus_0
  id: fcdproplus_fcdproplus
  parameters:
    freq: RxFrequency
    if_gain: Ifgain
    lnaswitch: '1'
    mixergainswitch: '1'
    ppm: ' PPM'
    unit: '1000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '1'
    gain: '5'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: RxFrequency*1000
    fftsize: '1024'
    gui_hint: 2,0,1,7
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: RxFrequency*1000
    fftsize: '1024'
    gui_hint: 1,0,1,7
    name: QT GUI Plot
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    gui_hint: 3,0,1,7
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [analog_fm_demod_cf_0, '0', audio_sink_0, '1']
- [fcdproplus_fcdproplus_0, '0', low_pass_filter_0, '0']
- [fcdproplus_fcdproplus_0, '0', qtgui_freq_sink_x_0, '0']
- [fcdproplus_fcdproplus_0, '0', qtgui_sink_x_0, '0']
- [fcdproplus_fcdproplus_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [qtgui_sink_x_0, freq, blocks_message_debug_0, print]
- [qtgui_sink_x_0, freq, fcdproplus_fcdproplus_0, freq]
- [qtgui_sink_x_0, freq, qtgui_sink_x_0, freq]

metadata:
  file_format: 1
