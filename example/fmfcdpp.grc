options:
  parameters:
    author: dl1ksv
    category: Custom
    generate_options: qt_gui
    id: FMRadio
    title: FM radio to test FCDPROplus
  states: {}

blocks:
- name: Ifgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: IFGain
    min_len: '45'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '59'
    value: '10'
    widget: counter
  states: {}
- name: Lna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label0: 'On'
    label1: 'Off'
    num_opts: '2'
    option1: '0'
    type: int
    value: '1'
  states: {}
- name: Mixergain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label0: 'On'
    label1: 'Off'
    num_opts: '2'
    option1: '0'
    type: int
    value: '1'
  states: {}
- name: RxFrequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Set Frequency '
    orient: Qt.Horizontal
    start: '80000'
    step: '1'
    stop: '146000'
    value: '94300'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: fcdproplus_fcdproplus_0
  id: fcdproplus_fcdproplus
  parameters:
    freq: RxFrequency
    if_gain: Ifgain
    lnaswitch: Lna
    mixergainswitch: Mixergain
    ppm: ' 0'
    unit: '1000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '60000'
    decim: '1'
    gain: '5'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: RxFrequency*1000
    fftsize: '1024'
    gui_hint: 1,0,1,7
    name: QT GUI Plot
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_pll_0, '1', audio_sink_0, '1']
- [fcdproplus_fcdproplus_0, '0', low_pass_filter_0, '0']
- [fcdproplus_fcdproplus_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [qtgui_sink_x_0, freq, fcdproplus_fcdproplus_0, freq]
- [qtgui_sink_x_0, freq, qtgui_sink_x_0, freq]

metadata:
  file_format: 1
