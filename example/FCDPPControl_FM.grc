options:
  parameters:
    author: dl1ksv
    description: Example of an FM receiver,using the Fcdproplus Control Block
    generate_options: qt_gui
    id: fcdControl
    title: FM Receiver,
  states: {}

blocks:
- name: RxFrequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Set Frequency '
    orient: Qt.Horizontal
    start: '80000'
    step: '100'
    stop: '146000'
    value: '94300'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_fm_demod_cf_1
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1'
    tau: '75e-6'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    device_name: default
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:2,0
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: fcdproplus_control_0
  id: fcdproplus_control
  parameters:
    freq: RxFrequency*1000
    if_gain: '8'
    lnaswitch: '1'
    mixergainswitch: '1'
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    gain: '5'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: RxFrequency*1000
    fftsize: '1024'
    gui_hint: 1,0,1,4
    name: QT GUI Plot
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fm_demod_cf_1, '0', audio_sink_1, '0']
- [analog_fm_demod_cf_1, '0', audio_sink_1, '1']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', low_pass_filter_1, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_1, '0', analog_fm_demod_cf_1, '0']
- [qtgui_sink_x_1, freq, blocks_message_debug_0, print]
- [qtgui_sink_x_1, freq, fcdproplus_control_0, freq]
- [qtgui_sink_x_1, freq, qtgui_sink_x_1, freq]

metadata:
  file_format: 1
